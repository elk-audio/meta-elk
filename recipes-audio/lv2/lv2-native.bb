
inherit native

require ${BPN}.inc
