# CMake append

EXTRA_OECMAKE += "-DBUILD_CursesDialog=1"
