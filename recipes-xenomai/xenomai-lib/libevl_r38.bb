# Libevl version R38
SRCREV = "7163b9e5f4797a313ee8db9e4d2260dcd29d06ef"
PV = "r38"

require libevl.inc
