SUMMARY = "sushi-webui frontend (Svelte 5 + Vite), build-time only"
DESCRIPTION = "Builds web/dist on the build host. The result is staged in the \
native sysroot and embedded into the sushi-webui binary (go:embed)."

require sushi-webui.inc

# Every npm dependency, with its integrity hash, is pinned by the shrinkwrap
# (a copy of web/package-lock.json at SRCREV; refresh it when bumping SRCREV)
# and fetched as a tarball: wrynose's bitbake has no usable npmsw fetcher.
# Generated by update-npm-deps.py.
SRC_URI += "file://npm-shrinkwrap.json"
require sushi-webui-npm-deps.inc

# The npm package is the web/ subdirectory of the repository.
S = "${UNPACKDIR}/${BP}/web"
LIC_FILES_CHKSUM = "file://../LICENSE;md5=216109e2c1c3eaf57de2bfc18c11c9f8"

inherit native

DEPENDS = "nodejs-native"

FRONTEND_STAGING_DIR = "${datadir}/sushi-webui-frontend"

do_configure() {
    # Fail early if the shrinkwrap is out of sync with the pinned sources.
    if ! cmp -s ${S}/package-lock.json ${UNPACKDIR}/npm-shrinkwrap.json; then
        bbfatal "files/npm-shrinkwrap.json differs from web/package-lock.json at SRCREV ${SRCREV}"
    fi

    # What `npm ci` would do, without npm: the tarballs hold a top-level
    # "package/" directory
    rm -rf ${S}/node_modules
    for entry in ${NPM_PACKAGES}; do
        dest=${S}/${entry%%=*}
        install -d $dest
        tar -xzf ${UNPACKDIR}/${entry#*=} -C $dest --strip-components=1
    done
}

do_compile() {
    cd ${S}
    export HOME=${WORKDIR}
    export NODE_ENV=production
    node node_modules/vite/bin/vite.js build
    test -f dist/index.html || bbfatal "vite did not produce dist/index.html"
}

do_install() {
    install -d ${D}${FRONTEND_STAGING_DIR}/dist
    cp -R ${S}/dist/. ${D}${FRONTEND_STAGING_DIR}/dist/
}
