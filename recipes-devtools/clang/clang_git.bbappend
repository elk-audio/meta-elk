# Set Clang parallel make options

PARALLEL_MAKE="-j 4"
