SUMMARY = "Web control surface for the Sushi plugin host"
DESCRIPTION = "Go backend bridging Sushi to a Svelte frontend over WebSocket. \
The frontend is embedded in the binary. The sushi-webui-setup package carries \
the systemd services that run Sushi with an empty session, the backend on \
port 8081 and a monitor that connects hardware MIDI controllers to Sushi. \
None of the services is enabled by default; elk-wifi-provisioning can enable \
them over BLE."

require sushi-webui.inc
# Pinned Go module sources, generated by update-go-mods.py
require sushi-webui-go-mods.inc

SRC_URI += "\
    file://sushi-webui-engine.service \
    file://sushi-webui.service \
    file://sushi-midi-autoconnect \
    file://sushi-midi-autoconnect.service \
    file://sushi-empty-session.json \
    file://installed_plugins.json \
"

# sushi-webui-frontend-native: web/dist, embedded with go:embed
# virtual/${TUNE_PKGARCH}-go: Go cross compiler, >= 1.25 is required by the dependencies
DEPENDS = "virtual/${TUNE_PKGARCH}-go sushi-webui-frontend-native"

inherit goarch systemd

GO_PROXY_DIR = "${WORKDIR}/go-proxy"

do_configure() {
    # Lay the fetched module files out as a file:// GOPROXY
    rm -rf ${GO_PROXY_DIR}
    for m in ${GO_MODULES}; do
        path=${m%@*}
        ver=${m#*@}
        flat=$(echo "$path" | sed 's,/,__,g')
        install -d ${GO_PROXY_DIR}/$path/@v
        for ext in info mod zip; do
            cp ${UNPACKDIR}/gomod__${flat}__${ver}.$ext ${GO_PROXY_DIR}/$path/@v/$ver.$ext
        done
    done

    # Embed the frontend built by sushi-webui-frontend-native
    rm -rf ${S}/web/dist
    cp -R ${STAGING_DATADIR_NATIVE}/sushi-webui-frontend/dist ${S}/web/dist
}

do_compile() {
    # Pure Go, statically linked: no target C toolchain involved
    export GOOS=${TARGET_GOOS} GOARCH=${TARGET_GOARCH} GOARM=${TARGET_GOARM}
    export CGO_ENABLED=0
    # Offline, reproducible: only the pinned modules, verified against go.sum
    export GOTOOLCHAIN=local GOPROXY=file://${GO_PROXY_DIR} GOSUMDB=off
    export GOFLAGS="-modcacherw -mod=readonly"
    export GOMODCACHE=${WORKDIR}/go-mod-cache GOCACHE=${WORKDIR}/go-cache
    export GOTELEMETRY=off HOME=${WORKDIR}

    cd ${S}
    ${HOST_PREFIX}go build -buildvcs=false -trimpath -ldflags "-s -w" \
        -o ${B}/sushi-webui ./cmd/sushi-webui
}

do_install() {
    install -d ${D}${bindir}
    install -m 0755 ${B}/sushi-webui ${D}${bindir}/sushi-webui
    install -m 0755 ${UNPACKDIR}/sushi-midi-autoconnect ${D}${bindir}/

    install -d ${D}${systemd_system_unitdir}
    install -m 0644 ${UNPACKDIR}/sushi-webui-engine.service ${D}${systemd_system_unitdir}/
    install -m 0644 ${UNPACKDIR}/sushi-webui.service ${D}${systemd_system_unitdir}/
    install -m 0644 ${UNPACKDIR}/sushi-midi-autoconnect.service ${D}${systemd_system_unitdir}/

    install -d ${D}${datadir}/sushi-webui
    install -m 0644 ${UNPACKDIR}/sushi-empty-session.json ${D}${datadir}/sushi-webui/
    install -m 0644 ${UNPACKDIR}/installed_plugins.json ${D}${datadir}/sushi-webui/
}

PACKAGES =+ "${PN}-setup"
FILES:${PN}-setup = "\
    ${bindir}/sushi-midi-autoconnect \
    ${systemd_system_unitdir}/sushi-webui-engine.service \
    ${systemd_system_unitdir}/sushi-webui.service \
    ${systemd_system_unitdir}/sushi-midi-autoconnect.service \
    ${datadir}/sushi-webui \
"
# aconnect for the MIDI monitor
RDEPENDS:${PN}-setup = "${PN} sushi bash alsa-utils-aconnect"

# Installed, but off until asked for (see elk-wifi-provisioning)
SYSTEMD_PACKAGES = "${PN}-setup"
SYSTEMD_SERVICE:${PN}-setup = "sushi-webui-engine.service sushi-webui.service sushi-midi-autoconnect.service"
SYSTEMD_AUTO_ENABLE = "disable"

# Static Go binary, already stripped by -ldflags "-s -w"
INSANE_SKIP:${PN} += "ldflags already-stripped"
INHIBIT_PACKAGE_STRIP = "1"
INHIBIT_PACKAGE_DEBUG_SPLIT = "1"
