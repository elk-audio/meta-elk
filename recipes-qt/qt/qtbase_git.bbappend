# Qt base append
 
PACKAGECONFIG:append = "\
    gbm \
    kms \
    sql-sqlite \
    accessibility \
    eglfs \
    fontconfig \
    gles2 \
    linuxfb \
"
