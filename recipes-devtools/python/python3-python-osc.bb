SUMMARY = "Recipe for python osc module"
HOMEPAGE = "https://github.com/attwad/python-osc"
SECTION = "devel/python"

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/BSD-3-Clause;md5=550794465ba0ec5312d6919e203a55f9"

PV = "1.7.4"
SRC_URI[md5sum] = "90c963deb9b07e9fbfe0df5ccf21e882"
SRC_URI[sha256sum] = "760f9d7a8c586a5347eb309336df08b308892cc6ca558b0874e7594bcb07d032"

inherit pypi setuptools3

