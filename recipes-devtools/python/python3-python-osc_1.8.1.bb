SUMMARY = "Open Sound Control server and client implementations in pure Python"
HOMEPAGE = "https://github.com/attwad/python-osc"
SECTION = "devel/python"

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/BSD-3-Clause;md5=550794465ba0ec5312d6919e203a55f9"

SRC_URI[md5sum] = "ce1c826c6c395e3864acabdd088a365a"
SRC_URI[sha256sum] = "ebd6b7cf8ae387380f48e9d6d7369bad1c176a1af6608efd7888b50b4f0e74ad"

inherit pypi setuptools3
